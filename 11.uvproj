# Keil uVision project 11.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 12 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s delay.c dht11.c edit.c exint.c GSM.c i2c_eeprom.c i2c_peripheral.c kpm.c lcd1.c pro_main.c UART_INT.c rtc.c dummy_pro_main.c
